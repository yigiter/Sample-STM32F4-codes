# Keil uVision project I2CLib.uvproj, settings and files
target I2CLib (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: I2CLib
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\Inc;..\..\STMLib\STM32F4xx_StdPeriph_Driver\inc;..\..\STMLib\CMSIS\ST\STM32F4xx\Include;..\..\STMLib\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./Src/: main.c EvalBoard.c
  group STM
    ./Src/: startup_stm32f4xx.s system_stm32f4xx.c
    ../../STMLib/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c
  group I2CLib
    ./Src/: I2CLib.c
